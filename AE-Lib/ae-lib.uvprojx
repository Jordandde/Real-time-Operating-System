# Keil uVision project ae-lib.uvprojx, settings and files
target AE Lib SIM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ae-lib-sim (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ECE350_P4
  c include: ..\include;..\include\bsp\LPC1768
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Documentation
    ./doc/: Abstract.txt G99-TS100.log G39-TS4.log G39-TS5.log G39-TS6.log
  group AE
    ./src/ae/: ae.c ae_tasks_util.c ae_timer.c ae_util.c
    ./src/: main.c
  group AE-inactive-public
    ./src/ae/: ae_tasks100_G99.c ae_tasks300_G99.c ae_tasks200_G99.c
  group AE-active
    ./src/ae/: ae_tasks10_G39.c
  group AE-inactive-stu
    ./src/ae/: ae_tasks12_G39.c ae_tasks11_G39.c ae_tasks300_med_tasks_G39.c ae_tasks7_G39.c ae_tasks.c ae_tasks8_G39.c ae_tasks9_G39.c
target AE Lib RAM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: as above
  output: ae-lib-ram (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ECE350_P4
  c include: ..\include;..\include\bsp\LPC1768
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
